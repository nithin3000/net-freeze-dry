# Keil uVision project Capinter.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: nRF51422_xxAB Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: Capinter +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 SETUPA BOARD_NRF6310
  c misc: --c99
  c include: C:\Keil\ARM\Device\Nordic\nrf51422\Include;C:\Keil\ARM\Device\Nordic\nrf51422\Source;..\..\..\Code+;C:\Keil\ARM\Device\Nordic\nrf51422\Include\ext_sensors;..\..\Capinterface_tx_v2;C:\Keil\ARM\ARMCC\include;C:\Keil\ARM\Device\Nordic\nrf51422\Include\ant\softdevice;C:\Keil\ARM\Device\Nordic\nrf51422\Include\ant;..\..\Capinterface_tx_v3_PCB_sing;C:\Keil\ARM\Device\Nordic\nrf51422\Source\spi_master
  library: MicroLIB
  memory RVCT4: ROM 0x20000 size 0x20000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Main
    ../: PCAPint_main.c
  group core
    ./: arm_startup_nrf51.s
    C:/Keil/ARM/Device/Nordic/nrf51422/Source/templates/: system_nrf51.c
  group New Group
    C:/Keil/ARM/Device/Nordic/nrf51422/Source/nrf_delay/: nrf_delay.c
    C:/Keil/ARM/Device/Nordic/nrf51422/Source/spi_master/: spi_master.c
    C:/Keil/ARM/Device/Nordic/nrf51422/Source/ext_sensors/nRF6350/: nRF6350.c
    C:/Keil/ARM/Device/Nordic/nrf51422/Source/twi_master/: twi_sw_master.c
